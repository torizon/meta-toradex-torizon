RDEPENDS:packagegroup-core-full-cmdline-utils:remove = "\
    bc \
    cpio \
    findutils \
    gawk \
    grep \
    mc \
    mc-fish \
    mc-helpers \
    mc-helpers-perl \
    mc-shell \
"

RDEPENDS:packagegroup-core-full-cmdline-multiuser:remove = "\
    gzip \
"
