PACKAGECONFIG:remove = "docker-plugin"
