# NOTE: make deployed file layout compatible with Torizon scripts
do_deploy[sstate-outputdirs] = "${DEPLOY_DIR_IMAGE}"
