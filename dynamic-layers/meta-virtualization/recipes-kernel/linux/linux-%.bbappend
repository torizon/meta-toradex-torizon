do_kernel_metadata:prepend () {
    includes="$includes -I${WORKDIR}/recipe-sysroot-native/kcfg"
}