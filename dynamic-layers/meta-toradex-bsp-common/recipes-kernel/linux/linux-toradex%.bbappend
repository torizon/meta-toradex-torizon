require recipes-kernel/linux/linux-torizon.inc
require recipes-kernel/linux/linux-toradex-kmeta.inc
