TARGET_CFLAGS += "-I${STAGING_INCDIR}/libdrm"
TARGET_CXXFLAGS += "-I${STAGING_INCDIR}/libdrm"
