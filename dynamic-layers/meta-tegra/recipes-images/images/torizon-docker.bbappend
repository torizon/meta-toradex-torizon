do_image_tegraflash[depends] += " tegra-minimal-initramfs:do_image_complete"
