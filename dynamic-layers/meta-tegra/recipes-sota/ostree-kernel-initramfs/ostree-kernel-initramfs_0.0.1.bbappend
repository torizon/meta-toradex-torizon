INITRAMFS_FSTYPES:remove = "cpio.gz.cboot"
