require torizon-podman.bb
require torizon-dev.inc
DESCRIPTION = "Torizon OS Linux experimental image based on production image \
using Podman container engine (with debugging tools)."
