require torizon-docker.bb
require torizon-dev.inc
DESCRIPTION = "Torizon OS Linux with no containers pre-provisioned (with debugging tools)."
