# Only useful for Pinephone related products.
# Remove due to GPLv3 on this specific componenet.
RRECOMMENDS:${PN}-keymaps:remove = "${PN}-keymaps-pine"
