FILES:${PN}-rtl8723:append = " \
  ${nonarch_base_libdir}/firmware/rtw88/rtw8723*.bin* \
"
