# Remove gdbm due to GPLv3
PACKAGECONFIG:remove = "gdbm"
