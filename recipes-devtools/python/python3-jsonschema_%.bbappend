# prefer non gpl runtime dependencies
PACKAGECONFIG = "format-nongpl"
